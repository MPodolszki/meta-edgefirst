# Ensure EdgeFirst Python runtime components are present in phytec-vision-image.
IMAGE_INSTALL:append = " packagegroup-edgefirst-python"
